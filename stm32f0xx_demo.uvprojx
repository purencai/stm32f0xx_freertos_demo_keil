# Keil uVision project stm32f0xx_demo.uvprojx, settings and files
target stm32f0xx_demo (5060750::V5.06 update 6 (build 750)::ARMCC)
  device: STM32F070CBTx STMicroelectronics
  pack: Keil.STM32F0xx_DFP.2.0.0
  cpu: IRAM(0x20000000,0x00004000) IROM(0x08000000,0x00020000) CPUTYPE("Cortex-M0") CLOCK(12000000) ELITTLE
  output: stm32f0xx_demo +hex
  c flags: Optim=4 OneElfS=1 v6Lang=1 v6LangP=1 wLevel=2
  c define: USE_STDPERIPH_DRIVER,STM32F070xB
  c misc: --c99 --gnu
  c include: .\CMSIS\CM0\CoreSupport;.\CMSIS\CM0\DeviceSupport\ST\STM32F10x;.\Libraries\inc;.\FreeRTOSv9.0.0\Source\include;.\FreeRTOSv9.0.0\Source\portable\RVDS\ARM_CM0;.\FreeRTOSv9.0.0;.\Tasks\UserTasks;.\System;.\System\delay;.\System\sys;.\System\usart;.\Hardware\LED;.\Software
  memory RVCT4: ROM 0x8000000 size 0x20000
  memory RVCT9: RAM 0x20000000 size 0x4000
  scatter file: .\Objects\stm32f0xx_demo.sct
  group User
    ./User/: main.c
  group Tasks
    ./Tasks/UserTasks/: user_tasks.c usart_task.c led_task.c
  group System
    ./System/usart/: usart.c
    ./System/sys/: sys.c
    ./System/delay/: delay.c
  group Startup
    ./Startup/arm/: startup_stm32f070xb.s
  group CMSIS
    ./CMSIS/CM0/DeviceSupport/ST/STM32F10x/: system_stm32f0xx.c
  group Libraries
    ./Libraries/src/: stm32f0xx_adc.c stm32f0xx_can.c stm32f0xx_cec.c stm32f0xx_comp.c stm32f0xx_crc.c stm32f0xx_crs.c stm32f0xx_dac.c stm32f0xx_dbgmcu.c stm32f0xx_dma.c stm32f0xx_exti.c stm32f0xx_flash.c stm32f0xx_gpio.c stm32f0xx_i2c.c stm32f0xx_iwdg.c stm32f0xx_misc.c stm32f0xx_pwr.c stm32f0xx_rcc.c stm32f0xx_rtc.c stm32f0xx_spi.c stm32f0xx_syscfg.c stm32f0xx_tim.c stm32f0xx_usart.c stm32f0xx_wwdg.c
  group FreeRTOSv9.0.0/Source
    ./FreeRTOSv9.0.0/Source/: croutine.c event_groups.c list.c queue.c tasks.c timers.c
  group FreeRTOSv9.0.0/Port
    ./FreeRTOSv9.0.0/Source/portable/MemMang/: heap_4.c
    ./FreeRTOSv9.0.0/Source/portable/RVDS/ARM_CM0/: port.c
    ./FreeRTOSv9.0.0/: FreeRTOSConfig.h
  group Hardware
    ./Hardware/LED/: led.c
  group Software
    ./Software/: usart_loop_queue.c message_manager.c led_function.c
